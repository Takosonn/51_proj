# Keil uVision project 72.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 72 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 72.c delay.c delay.h LCD1602.c LCD1602.h timer0.c timer0.h
