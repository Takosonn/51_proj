# Keil uVision project 511.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 511 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 51.c delay.c delay.h nixie.c nixie.h
