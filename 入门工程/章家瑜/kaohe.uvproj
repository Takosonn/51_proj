# Keil uVision project kaohe.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: kaohe +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Buzzer.c Buzzer.h Delay.c Delay.h key.c key.h LCD1602.c LCD1602.h
