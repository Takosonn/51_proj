# Keil uVision project 1011.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1011 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: min.c LCD1602.c LCD1602.h DS1302.c DS1302.h
    ../82/: delay.c delay.h
